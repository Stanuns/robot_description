Commit message: add world map static transform publisher

File: urdf/diff_robot.urdf (robot description, URDF)
Before this commit: robot luxshare_robot, 10 links, 9 joints
Joints:
- joint laser_joint: origin xyz=0.11 0 0.055 -> xyz=0.11 0 0.055 rpy=0 0 0
